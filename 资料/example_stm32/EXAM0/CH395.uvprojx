# Keil uVision project CH395.uvprojx, settings and files
target Demo (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: CH395 +hex
  c flags: Optim=3
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group main
    ./: CH395.C
  group System
    ../SYSTEM/: stm32f10x_it.c System_Init.c STM32F10x.s
  group Library
    ../SYSTEM/: STM32F10xR.LIB
