# Keil uVision project CH395EVT.uvproj, settings and files
target Target 1 (MCS-51)
  device: SST89C58 SST
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF) CLOCK(33000000)
  output: CH395EVT +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\pubfile
  group Source Group 1
    ./: CH395.C
