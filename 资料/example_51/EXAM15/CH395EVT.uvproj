# Keil uVision project CH395EVT.uvproj, settings and files
target Target 1 (MCS-51)
  device: SST89E564RD SST
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: CH395EVT +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: CH395.C main.c ModuleConfig.c
