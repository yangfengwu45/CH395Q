# Keil uVision project CH395WEBSERVER.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STR912FAW44 STMicroelectronics
  cpu: IRAM(0x04000000-0x04017FFF) IROM(0x0-0x7FFFF) IROM2(0x400000-0x407FFF) CLOCK(25000000) CPUTYPE(ARM966E-S)
  output: CH395WEBSERVER +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x8000
  memory RVCT9: RAM 0x4000000 size 0x18000
  scatter file: .\SRC\CH563D64.SCF
  group seting
    ./SRC/: STARTUP.S SYSFREQ.C
    ./WEB/: CH395.C
  group app
    ./WEB/: HTTTPS.C
  group source
    ./WEB/: MAIN.C
