# Keil uVision project CH395MAIL.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: CH395 +hex
  c flags: Optimize=8 SizeSpeed=1
  group seting
    ./mail/: CH395.C
  group app
    ./mail/: ch395mail.c
  group source
    ./mail/: main.c
