# Keil uVision project CH395FTP_CLIENT.uvproj, settings and files
target Target 1 (MCS-51)
  device: SST89E564RD SST
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: ch395ftp +hex
  c flags: Optimize=8 SizeSpeed=1
  group seting
    ./FTP/: CH395.C
  group app
    ./FTP/: CH395FTP.c
  group source
    ./FTP/: MAIN.c
